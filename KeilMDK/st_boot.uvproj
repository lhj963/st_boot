# Keil uVision project st_boot.uvproj, settings and files
target st_boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: st_boot +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Source\device;..\Source\main;..\Source\drivers
  library: MicroLIB
  scatter file: .\st_boot.sct
  group device
    ../Source/device/: startup_stm32f10x_hd.s core_cm3.c
  group main
    ../Source/main/: main.c
  group apps
    ../Source/apps/: apps.c
  group drivers
    ../Source/drivers/: drivers.c
  group os
    ../Source/os/: cpu_c.c lfos.c cpu_s.s
